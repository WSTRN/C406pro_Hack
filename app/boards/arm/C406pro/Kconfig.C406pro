## app/boards/arm/C406pro/Kconfig.C406pro
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_C406PRO
	select SOC_NRF52840_QIAA
```
